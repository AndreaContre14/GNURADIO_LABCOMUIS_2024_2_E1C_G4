options:
  parameters:
    author: Daniel_Sarmiento
    generate_options: qt_gui
    id: ModulaciónFMRX
    output_language: python
    title: Demoduladora de emisoras
  states: {}

blocks:
- name: D
  id: variable
  parameters:
    value: '25'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de portadora
    start: 88E6
    step: 100E3
    stop: 108E6
    value: 90.7E6
  states: {}
- name: fcb
  id: variable_qtgui_range
  parameters:
    label: Frecuencia corte filtro
    start: 10E3
    step: 1E2
    stop: 100E3
    value: 100E3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6.25E6
  states: {}
- name: analog_fm_preemph_0
  id: analog_fm_preemph
  parameters:
    fh: '-1.0'
    samp_rate: samp_rate/D
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: samp_rate/D
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fcb
    decim: D
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/D
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    name: '"banda base"'
    nconnections: '2'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate/D)
    interp: '44100'
    type: fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_fm_preemph_0, '0', qtgui_freq_sink_x_1, '1']
- [analog_fm_preemph_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', analog_fm_preemph_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-810-g1ecb8565
